# Keil uVision project In_Lab_Work.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: In_Lab_Work
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: C:\ti\TivaWare_C_Series-2.2.0.295\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group
    ./: main.c tm4c123gh6pm.h MyInitiation.c MyInitiation.h LCD.c LCD.h
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Heap 10.4.3, CMSIS:CORE 5.5.0, Device:Startup 1.0.1
